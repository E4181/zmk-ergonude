## boards/shields/ergonude/Kconfig.defconfig
```kconfig
if SHIELD_ERGONUDE

config ZMK_KEYBOARD_NAME
    default "ergonude"
      
endif
```
